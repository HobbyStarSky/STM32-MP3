# Keil uVision project Music Player.uvprojx, settings and files
target Music Player (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Music Player +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\TOUCH;..\HARDWARE\REMOTE;..\HARDWARE\ADXL345;..\HARDWARE\DS18B20;..\HARDWARE\NRF24L01;..\HARDWARE\SRAM;..\MALLOC;..\HARDWARE\SD;..\FATFS\exfuns;..\FATFS\src;..\USMART;..\FATFS\src\option;..\HARDWARE\SDIO;..\HARDWARE\W25QXX;..\TEXT;..\HARDWARE\VS10XX;..\APP;..\HARDWARE\REMOTE;..\PICTURE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/VS10XX/: vs10xx.c
    ../HARDWARE/REMOTE/: remote.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_sdio.c stm32f10x_flash.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/src/option/: mycc936.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group APP
    ../APP/: mp3player.c
  group PICTURE
    ../PICTURE/: bmp.c decoded.c gif.c piclib.c tjpgd.c
